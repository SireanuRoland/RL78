# IAR project sw_pwm.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 4096
  General.GenDeviceSelect: R5F10PPJ RL78 - R5F10PPJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10ppj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    applilet3_src/: r_cg_dtc.c
  group cg/cg_src
    applilet3_src/: md_lnkr5f10pmg.xcl r_cg_adc.c r_cg_adc.h r_cg_adc_user.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_dtc.h r_cg_dtc_user.c r_cg_intc.c r_cg_intc.h r_cg_intc_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_main.c r_systeminit.c
  group src
    applilet3_src/: r_main_pwmTables.c
